# Keil uVision project stm32hal.h7.dualcore.uvprojx, settings and files
target amc.1cm7-v1A0 (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: amc1cm7_v1A0 (library)
  AfterMake: cmd.exe /C copy .\h7\m7\o\amc1cm7_v1A0.lib ..\lib\stm32hal.h7.amc1cm7.v1A0.lib
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMC1CM7 STM32HAL_DRIVER_V1A0 STM32H745xx CORE_CM7 USE_HAL_DRIVER
  c misc: -DSTM32HAL_USE_LOWLEVEL_DELAY
  c include: ..\api;..\src\driver\stm32h7-v1A0\inc;..\src\board\amc1cm7\v1A0\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
  group stm32hal
    ../src/stm32hal/: stm32hal.c lowlevel.c
  group driver-stm32h7-v1A0
    ../src/driver/stm32h7-v1A0/src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_gpio.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c
  group board-amc.1cm7-v1A0
    ../src/board/amc1cm7/v1A0/src/: board_amc1cm7_v1A0.c
  group board-amc.2cm4-V1A0
    ../src/board/amc2cm4/v1A0/src/: board_amc2cm4_v1A0.c
  group board-amcfocm7-v1A0
    ../src/board/amcfocm7/v1A0/src/: board_amcfocm7_v1A0.c stm32h7xx_hal_msp.c
  group board-amcfocm4-v1A0
    ../src/board/amcfocm4/v1A0/src/: board_amcfocm4_v1A0.c stm32h7xx_hal_msp.c
target amc.2cm4-v1A0 (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: amc2cm4_v1A0 (library)
  AfterMake: cmd.exe /C copy .\h7\m4\o\amc2cm4_v1A0.lib ..\lib\stm32hal.h7.amc2cm4.v1A0.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMC2CM4 STM32HAL_DRIVER_V1A0 STM32H745xx CORE_CM4 USE_HAL_DRIVER
  c misc: -DcherrypickFDCANv1B1 -DSTM32HAL_BOARD_AMC2C_V1A0_enableETH
  c include: ..\api;..\src\driver\stm32h7-v1A0\inc;..\src\board\amc2cm4\v1A0\inc
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  link misc: --diag_suppress=L6329
target amcfoc.m7-v1A0 (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: stm32hal_amcfocm7_v1A0 (library)
  AfterMake: cmd.exe /C copy .\h7-obj\stm32h745disco_v1A0\stm32hal_amcfocm7_v1A0.lib ..\lib\stm32hal.h7.amcfoc.m7.v1A0.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCFOCM7 STM32HAL_DRIVER_V1A0 STM32H745xx CORE_CM7 USE_HAL_DRIVER
  c misc: -DSTM32HAL_USE_LOWLEVEL_DELAY
  c include: ..\api;..\src\driver\stm32h7-v1A0\inc;..\src\board\amcfocm7\v1A0\inc;..\src\board\amcfocm7\v1A0\drv
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
target amcfoc.m4-v1A0 (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: stm32hal_amcfocm4_v1A0 (library)
  AfterMake: cmd.exe /C copy .\h7-obj\stm32h745disco_v1A0\stm32hal_amcfocm4_v1A0.lib ..\lib\stm32hal.h7.amcfoc.m4.v1A0.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCFOCM4 STM32HAL_DRIVER_V1A0 STM32H745xx CORE_CM4 USE_HAL_DRIVER
  c misc: -DSTM32HAL_USE_LOWLEVEL_DELAY
  c include: ..\api;..\src\driver\stm32h7-v1A0\inc;..\src\board\amcfocm4\v1A0\inc;..\src\board\amcfocm4\v1A0\drv
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.6.0
