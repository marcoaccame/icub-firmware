# Keil uVision project osal.uvprojx, settings and files
target osal.cm4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: osal_cm4 (library)
  AfterMake: cmd.exe /C copy .\Obj\osal_cm4.lib .\lib\osal.cm4.lib
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM4 __CORTEX_M4F __FPU_PRESENT=1 OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --diag_suppress 3731
  c include: .\api;..\..\..\midware\oosiit\api;..\..\..\midware\oosiit\src\cmsis-rtx-modified\cm;..\..\..\midware\oosiit\src\others;..\..\..\midware\eventviewer;..\..\..\lowlevel\hl-core\cmsis\api
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group oosiit
    ../../../midware/oosiit/src/cmsis-rtx-modified/cm/: HAL_CM.c HAL_CM3.c HAL_CM4.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c SVC_Table.s
    ../../../midware/oosiit/src/others/: oosiit.c rt_iit_AdvTimer.c rt_iit_changes.c rt_iit_memory.c oosiit_storage.c
  group osal
    ./src/: osal-oosiit.c
target osal.cm4.dbg (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: osal_cm4_dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\osal_cm4_dbg.lib .\lib\osal.cm4.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM4 __CORTEX_M4F __FPU_PRESENT=1 OOSIIT_DBG_ENABLE OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --diag_suppress 3731
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target osal.cm4.tracefatalerror (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: osal_cm4_trace (library)
  AfterMake: cmd.exe /C copy .\Obj\osal_cm4_trace.lib .\lib\osal.cm4.trace.lib
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: as above
  c misc: --diag_suppress 3731 -DFATALERR_trace_RTOS
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.0
