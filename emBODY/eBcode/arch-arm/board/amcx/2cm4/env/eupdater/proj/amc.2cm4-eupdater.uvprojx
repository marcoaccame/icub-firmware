# Keil uVision project amc.2cm4-eupdater.uvprojx, settings and files
target amc.2cm4-slave (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: h7disco +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMC2CM4 STM32HAL_DRIVER_V1A0
  c misc: -Ddualcore_BOOT_cm7master -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\embot\hw;..\..\..\..\..\..\embot\os;..\..\..\..\..\..\embot\app;..\..\..\..\..\..\embot\app;..\..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\bsp;..\..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amc.2cm4-template-appl.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: updater-embot-main.cpp
  group eupdater-code
    ../src/eupdater/: eOcfg_sm_cangtw.c eupdater_cangtw.c eupdater_parser.c eupdater-info.c updater-core.c
    ../../../../../../embot/hw/: hal_embot.cpp
  group stm32hal
    ../cfg/: stm32hal.h7.startup.amc.CM4.s
    ../../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amc2cm4.v1A0.lib
  group rtos
    ../../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw-core
    ../../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_dualcore.cpp
  group embot::os
    ../../../../../../embot/os/: embot_os_eom.cpp embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::app
    ../../../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_scope.cpp
    ../../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw::bsp-core
    ../../../bsp/: system_stm32h7xx-cm4-cm7-gated.c embot_hw_bsp_amc2cm4.cpp embot_hw_bsp_DRIVER_amc2cm4.cpp embot_hw_dualcore_bsp_amc2cm4.cpp embot_hw_flash_bsp_amc2cm4.cpp embot_hw_gpio_bsp_amc2cm4.cpp embot_hw_led_bsp_amc2cm4.cpp embot_hw_timer_bsp_amc2cm4.cpp
  group embot::hw::lowlevel
    ../../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot:hw::bsp-others
    ../../../bsp/: embot_hw_spi_bsp_amc2cm4.cpp embot_hw_eeprom_bsp_amc2cm4.cpp embot_hw_encoder_bsp_amc2cm4.cpp embot_hw_can_bsp_amc2cm4.cpp
  group embot::hw-others
    ../../../../../../embot/hw/: embot_hw_spi.cpp embot_hw_eeprom.cpp embot_hw_chip_M95512DF.cpp embot_hw_encoder.cpp embot_hw_chip_AS5045.cpp embot_hw_chip_MA730.cpp embot_hw_chip_KSZ8563.cpp embot_hw_eth.cpp embot_hw_timer.cpp
  group embot:hw::eth::bsp
    ../../../bsp/: embot_hw_eth_bsp_amc2cm4.cpp
    ../../../bsp/ipaldrv/: ipal_hal_eth_stm32h7.c EMAC_STM32H7xx_KSZ8563.c PHY_KSZ8563.c ethram.c
  group xtra->ipal
    ../../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.lwip.h7.cm4.lib
    ../cfg/: ipal_cfg2.cpp
  group xtra->eo-core
    ../../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group xtra->eo-mee-embot
    ../../../../../../embobj/core/exec/multitask/embot/: EOMmutex.embot.cpp EOMtask.embot.cpp
  group xtra->eo-ipnet
    ../../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group xtra->hal-fake
    ../src/hal-fake/: halfake.cpp
  group eo-updaterprotocol
    ../../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoUpdaterProtocol.c
  group eo-theEnvironment
    ../../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
    ../../../../../../libs/highlevel/services/embenv/src/: eEsharedServices.c eEcommon.c shalBASE.c shalINFO.c shalPART.c
target amc.2cm4-master (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: amc.2cm4.master +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMC2CM4 STM32HAL_DRIVER_V1A0 USE_EMBOT_HW
  c misc: -Ddualcore_BOOT_cm4master -DEMBOBJ_USE_EMBOT  -DIPAL_use_cfg2 -Ddont_USE_IPADDR_FROM_IPAL_CFG_ -DEMBOT_USE_rtos_osal -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\embot\hw;..\..\..\..\..\..\embot\os;..\..\..\..\..\..\embot\app;..\..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\bsp;..\..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\bsp\ipaldrv;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\..\embobj\plus\ipnet;..\cfg;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\src\eupdater
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amc.2cm4-eupdaterl.sct
  link misc: --diag_suppress=L6329
