# Keil uVision project amc.1cm7-bldc.uvprojx, settings and files
target amc.1cm7-master (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: amc.1cm7.master +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMC1CM7 STM32HAL_DRIVER_V1A0
  c misc: -Ddualcore_BOOT_cm7master -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\embot\hw;..\..\..\..\..\..\embot\os;..\..\..\..\..\..\embot\app;..\..\..\..\..\..\embot\app;..\..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\bsp;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-basic.cpp amc1cm7-main2.cpp
  group stm32hal
    ../cfg/: stm32hal.h7.startup.amc.CM7.s
    ../../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amc1cm7.v1A0.lib
  group rtos
    ../../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw
    ../../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw_dualcore.cpp embot_hw_can.cpp embot_hw_icc_ltr.cpp embot_hw_icc_mem.cpp embot_hw_icc_printer.cpp embot_hw_icc_sig.cpp embot_hw_mtx.cpp embot_hw_button.cpp embot_hw_motor.cpp embot_hw_timer.cpp embot_hw_testpoint.cpp
  group embot::os
    ../../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::app
    ../../../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_scope.cpp
    ../../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw::bsp
    ../../../bsp/: system_stm32h7xx-cm4-cm7-gated.c embot_hw_bsp_amc1cm7.cpp embot_hw_bsp_DRIVER_amc1cm7.cpp embot_hw_dualcore_bsp_amc1cm7.cpp embot_hw_flash_bsp_amc1cm7.cpp embot_hw_led_bsp_amc1cm7.cpp embot_hw_bsp_gpio_amc1cm7.cpp embot_hw_can_bsp_amc1cm7.cpp embot_hw_mtx_bsp_amc1cm7.cpp embot_hw_icc_bsp_amc1cm7.cpp embot_hw_button_bsp_amc1cm7.cpp embot_hw_motor_bsp_amc1mc7.cpp embot_hw_timer_bsp_amc1cm7.cpp
  group embot::hw::lowlevel
    ../../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp::motorhal
    ../../../bsp/motorhal/: motorhal.cpp motorhal_config.c adcm.c enc.c hall.c pwm.c motorhal_faults.c
  group embot::app::board::amc1cm7
    ../src/app-board-amc1cm7/: embot_app_board_amc1cm7_info.cpp embot_app_board_amc1cm7_mbd.demo.cpp embot_app_board_amc1cm7_mbd.icc.cpp embot_app_board_amc1cm7_test.cpp embot_app_board_amc1cm7_theCANagentCORE.cpp embot_app_board_amc1cm7_theMBD.cpp
  group embot::app::bldc
    ../../../../../../embot/app/eth/: embot_app_eth_theICCservice.cpp
    ../../../../../../embot/app/bldc/: embot_app_bldc_theCOMMcanicc.cpp embot_app_bldc_theApplication.cpp embot_app_bldc_theCTRL.cpp embot_app_bldc_theMSGbroker.cpp
  group embot::prot::can
    ../../../../../../embot/prot/can/: embot_prot_can.cpp embot_prot_can_analog_periodic.cpp embot_prot_can_analog_polling.cpp embot_prot_can_bootloader.cpp embot_prot_can_inertial_periodic.cpp embot_prot_can_motor_periodic.cpp embot_prot_can_motor_polling.cpp embot_prot_can_skin_periodic.cpp
  group embot::app-others
    ../../../../../../embot/app/: embot_app_application_theCANparserCORE.cpp embot_app_application_theCANtracer.cpp
  group mbd::sharedutils
    ../../../../../../mbd/amcbldc/sharedutils/: const_params.cpp rt_hypotf.cpp rt_hypotf_snf.cpp rt_nonfinite.cpp rt_roundd.cpp rt_roundd_snf.cpp rt_roundf.cpp rt_roundf_snf.cpp rtGetInf.cpp rtGetNaN.cpp uMultiWord2Double.cpp uMultiWordShl.cpp rtw_enable_disable_motors.c rtw_motor_config.c
  group mbd::can-encoder
    ../../../../../../mbd/amcbldc/can-encoder/: can_encoder.cpp
  group mbd::can-decoder
    ../../../../../../mbd/amcbldc/can-decoder/: can_decoder.cpp
  group mbd::supervisor-rx
    ../../../../../../mbd/amcbldc/supervisor-rx/: SupervisorFSM_RX.cpp SupervisorFSM_RX_data.cpp
  group mbd::supervisor-tx
    ../../../../../../mbd/amcbldc/supervisor-tx/: SupervisorFSM_TX.cpp
  group mbd::control-outer
    ../../../../../../mbd/amcbldc/control-outer/: control_outer.cpp
  group mbd::control-foc
    ../../../../../../mbd/amcbldc/control-foc/: control_foc.cpp control_foc_data.cpp FOCInnerLoop.cpp
  group mbd::estimator
    ../../../../../../mbd/amcbldc/estimator/: estimation_velocity.cpp
  group mbd::filter-current
    ../../../../../../mbd/amcbldc/filter-current/: filter_current.cpp
  group mbd::amc-bldc
    ../../../../../../mbd/amcbldc/amc-bldc/: AMC_BLDC.cpp
target amc.1cm7-bldc (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: amc.1cm7 +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMC1CM7 STM32HAL_DRIVER_V1A0
  c misc: -Ddualcore_BOOT_cm4master -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\embot\hw;..\..\..\..\..\..\embot\os;..\..\..\..\..\..\embot\app;..\..\..\..\..\..\embot\app;..\..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\bsp;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\motorhal;..\..\..\..\..\..\embot\app\bldc;..\..\..\..\..\..\embot\prot\can;..\..\..\..\..\..\embot\app\eth;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\src\app-board-amc1cm7;..\..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\..\mbd\amcbldc\amc-bldc;..\..\..\..\..\..\mbd\amcbldc\sharedutils;..\..\..\..\..\..\mbd\amcbldc\can-decoder;..\..\..\..\..\..\mbd\amcbldc\can-encoder;..\..\..\..\..\..\mbd\amcbldc\supervisor-rx;..\..\..\..\..\..\mbd\amcbldc\supervisor-tx;..\..\..\..\..\..\mbd\amcbldc\control-outer;..\..\..\..\..\..\mbd\amcbldc\control-foc;..\..\..\..\..\..\mbd\amcbldc\filter-current;..\..\..\..\..\..\mbd\amcbldc\estimator;..\..\..\..\..\..\libs\lowlevel\cmsis\dsp\v160\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amc.1cm7-application.sct
  link misc: --diag_suppress=L6329
