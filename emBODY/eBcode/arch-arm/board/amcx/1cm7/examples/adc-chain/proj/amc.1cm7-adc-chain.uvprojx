# Keil uVision project amc.1cm7-adc-chain.uvprojx, settings and files
target amc.1cm7-master (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: amc.1cm7.master +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMC1CM7 STM32HAL_DRIVER_V1A0
  c misc: -Ddualcore_BOOT_cm7master -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\embot\hw;..\..\..\..\..\..\embot\os;..\..\..\..\..\..\embot\app;..\..\..\..\..\..\embot\app;..\..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\bsp;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-basic.cpp
  group stm32hal
    ../cfg/: stm32hal.h7.startup.amc.CM7.s
    ../../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amc1cm7.v1A0.lib
  group rtos
    ../../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw
    ../../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw_dualcore.cpp
  group embot::os
    ../../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::app
    ../../../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_scope.cpp
    ../../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw::bsp
    ../../../bsp/: system_stm32h7xx-cm4-cm7-gated.c embot_hw_bsp_amc1cm7.cpp embot_hw_bsp_DRIVER_amc1cm7.cpp embot_hw_dualcore_bsp_amc1cm7.cpp embot_hw_flash_bsp_amc1cm7.cpp embot_hw_led_bsp_amc1cm7.cpp embot_hw_bsp_gpio_amc1cm7.cpp
  group embot::hw::lowlevel
    ../../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::motor
    ../../../../../../embot/hw/: embot_hw_motor.cpp embot_hw_timer.cpp
    ../../../bsp/: embot_hw_motor_bsp_amc1mc7.cpp embot_hw_timer_bsp_amc1cm7.cpp
    ../../../bsp/motorhal/: motorhal.cpp adcm.c enc.c hall.c motorhal_config.c motorhal_faults.c pwm.c
target amc.1cm7-slave (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: amc.1cm7 +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMC1CM7 STM32HAL_DRIVER_V1A0
  c misc: -Ddualcore_BOOT_cm4master -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\embot\hw;..\..\..\..\..\..\embot\os;..\..\..\..\..\..\embot\app;..\..\..\..\..\..\embot\app;..\..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\bsp;..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\motorhal
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
